FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://tcu-boot.cfg"
